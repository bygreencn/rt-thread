# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC1100 (ARM-ADS)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: rtthread-lpc1100
  c flags: Optim=1
  c include: .;.\startup;..\..\include;..\..\components\CMSIS\Include;.\platform
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: startup.c rtconfig.h application.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group LPC1100
    ./startup/: LPC11xx.h system_LPC11xx.h startup_LPC11xx.s system_LPC11xx.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Platform
    ./platform/: gpio.c gpio.h type.h uart.c uart.h board.c board.h
